# IAR project app_sdk15_usbd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52840_XXAA; S140; BOARD_GI17003; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; CONFIG_GPIO_AS_PINRESET; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; SOFTDEVICE_PRESENT; SWI_DISABLE0; DEBUG; NRF_PWR_MGMT_CONFIG_FPU_SUPPORT_ENABLED; BLE_STACK_SUPPORT_REQD; CONFIG_NFCT_PINS_AS_GPIOS; NRF_SD_BLE_API_VERSION=6; BOARD_CUSTOM
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_channel_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_encryption; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_fs; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_key_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_key_manager\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_common\ant_request_controller; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_common\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_search_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_state_indicator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_advertising; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_db_discovery; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_dtm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_link_ctx_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_racp; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_radio_notification; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_services\ble_nus; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_services\ble_nus_c; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\common; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_gatt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_qwr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_scan; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\peer_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\radio_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\sdio; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\sdio\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\spi_master; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\twi_master\deprecated; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\twi_master\deprecated\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic_fifo; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic_flags; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\balloc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\block_dev; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\bootloader; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\bsp; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\button; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\cli; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crc16; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crc32; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crypto; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\csense; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\csense_drv; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\delay; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\ecc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_libuarte; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_section_vars; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_task_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fds; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fifo; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fstorage; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\gfx; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\gpiote; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\hardfault; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\hci; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\led_softblink; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\log; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\log\src; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\low_power_pwm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mem_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\memobj; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mpu; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mutex; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\pwm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\pwr_mgmt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\queue; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\ringbuf; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\scheduler; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sdcard; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sensorsim; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\serial; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sh256; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\simple_timer; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\slip; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\strerror; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\spi_mngr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\stack_guard; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\stack_info; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\strerror; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\svc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\timer; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\twi_mngr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\twi_sensor; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\uart; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\audio; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\cdc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\cdc\acm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\dummy; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\generic; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\kbd; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\mouse; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\msc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\nrf_dfu_trigger; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\util; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\common; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\mbr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers\nrf52; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\toolchain\cmsis\include; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\external\segger_rtt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\external\fprintf; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\external\utf_converter; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\hal; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\mdk; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\drivers; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\drivers\include; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\soc; config; config\legacy; board; source; source\boot_common; D:\SourceRespo\haoyi_lib\adc; D:\SourceRespo\haoyi_lib\inertial; D:\SourceRespo\BSXlite_Cortex_M3_M4_M4F\algo\algo_bsx\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_channel_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_encryption; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_fs; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_key_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_key_manager\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bpwr\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_bsc\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_common\ant_request_controller; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_common\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_hrm\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\pages; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\simulator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_profiles\ant_sdm\utils; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_search_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ant\ant_state_indicator; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_advertising; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_db_discovery; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_dtm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_link_ctx_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_racp; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_radio_notification; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_services\ble_nus; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\ble_services\ble_nus_c; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\common; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_gatt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_qwr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\nrf_ble_scan; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\ble\peer_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\radio_config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\sdio; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\sdio\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\spi_master; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\twi_master\deprecated; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\drivers_nrf\twi_master\deprecated\config; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic_fifo; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\atomic_flags; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\balloc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\block_dev; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\bootloader; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\bsp; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\button; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\cli; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crc16; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crc32; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\crypto; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\csense; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\csense_drv; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\delay; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\ecc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_libuarte; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_section_vars; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\experimental_task_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fds; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fifo; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\fstorage; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\gfx; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\gpiote; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\hardfault; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\hci; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\led_softblink; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\log; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\log\src; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\low_power_pwm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mem_manager; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\memobj; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mpu; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\mutex; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\pwm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\pwr_mgmt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\queue; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\ringbuf; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\scheduler; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sdcard; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sensorsim; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\serial; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\sh256; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\simple_timer; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\slip; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\strerror; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\spi_mngr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\stack_guard; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\stack_info; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\strerror; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\svc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\timer; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\twi_mngr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\twi_sensor; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\uart; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\audio; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\cdc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\cdc\acm; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\dummy; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\generic; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\kbd; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\hid\mouse; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\msc; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\usbd\class\nrf_dfu_trigger; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\libraries\util; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\common; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\mbr; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers\nrf52; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\components\toolchain\cmsis\include; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\external\segger_rtt; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\external\fprintf; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\hal; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\mdk; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\drivers; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\drivers\include; D:\SourceRespo\NRF\nRF5_SDK_15.3.0_59ac345\modules\nrfx\soc; config; config\legacy; board; source; source\boot_common; D:\SourceRespo\haoyi_lib\adc; D:\SourceRespo\haoyi_lib\inertial; D:\SourceRespo\BSXlite_Cortex_M3_M4_M4F\algo\algo_bsx\Inc
  OBJCOPY.OOCOutputFile: 17003_bpwr_app_mvpv_190119.bin
  ILINK.IlinkOutputFile: 17003_bpwr_debug.out
  ILINK.IlinkIcfFile: D:\wsProj\17003_powerMeter\app\app_sdk15_usbd\usbd_ble_uart_iar_nRF5x.icf
  ILINK.IlinkAdditionalLibs: D:\SourceRespo\BSXlite_Cortex_M3_M4_M4F\algo\algo_bsx\Lib\libalgobsx3_CortexM4\libalgobsx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: 17003_bpwr.out
  group Application
    source/: main.c peripheral_if.c
    config/: sdk_config.h
  group Application/AD7124
    $extsource$/haoyi_lib/adc/: ad7124.c
    source/: ad7124_cmd.c ad7124_config.h
  group Application/BIM160
    $extsource$/haoyi_lib/inertial/: bmi160.c bmi160.h
    source/: bmi160_cmd.c bmi160_cmd.h bmi160_config.h
  group Application/usbd_ble_central
    source/: app_ble_uart.c
  group Application/Bootloader
    source/bootloader/: antfs_ota.c bl_main.c bootloader.c bootloader_util_arm.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c pstorage.c version.c
  group Application/Fusion
    source/: fusion_bosch.c
  group Application/ota
    source/: ant_boot_settings_api.c ant_ota.c ota_main.c
  group Application/usbd_ble_peripheral
    source/: usbd_ble_uart_peripheral.c
  group Board
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/boards/: boards.c
    board/: gd17003.h
  group Board Support
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/bsp/: bsp.c bsp_btn_ant.c bsp_btn_ble.c
  group Device
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c system_nrf52840.h
  group external
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
  group nRF_ANT
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_channel_config/: ant_channel_config.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_encryption/: ant_encrypt_config.c ant_encrypt_negotiation_slave.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_key_manager/: ant_key_manager.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_search_config/: ant_search_config.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_stack_config/: ant_stack_config.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_state_indicator/: ant_state_indicator.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_fs/: antfs.c crc.c
  group nRF_ANT/profiles/bpwr
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_profiles/ant_bpwr/: ant_bpwr.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_profiles/ant_bpwr/pages/: ant_bpwr_common_data.c ant_bpwr_page_1.c ant_bpwr_page_16.c ant_bpwr_page_17.c ant_bpwr_page_18.c ant_bpwr_page_torque.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_profiles/ant_bpwr/simulator/: ant_bpwr_simulator.c
  group nRF_ANT/profiles/common
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_profiles/ant_common/pages/: ant_common_page_70.c ant_common_page_80.c ant_common_page_81.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ant/ant_profiles/ant_common/ant_request_controller/: ant_request_controller.c
  group nRF_BLE
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_advertising/: ble_advertising.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_db_discovery/: ble_db_discovery.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_racp/: ble_racp.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_radio_notification/: ble_radio_notification.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/nrf_ble_scan/: nrf_ble_scan.c
  group nRF_BLE/common
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
  group nRF_BLE/services
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_services/ble_nus/: ble_nus.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/ble/ble_services/ble_nus_c/: ble_nus_c.c
  group nRF_Drivers
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/modules/nrfx/drivers/src/: nrfx_adc.c nrfx_clock.c nrfx_comp.c nrfx_dppi.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_nfct.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_qspi.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_systick.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_wdt.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/modules/nrfx/soc/: nrfx_atomic.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Drivers/legacy
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_spis.c nrf_drv_swi.c nrf_drv_twi.c nrf_drv_uart.c
  group nRF_Libraries
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/button/: app_button.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/fifo/: app_fifo.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/gpiote/: app_gpiote.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/timer/: app_timer.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/uart/: app_uart.c app_uart_fifo.c retarget.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/atomic_fifo/: nrf_atfifo.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/atomic_flags/: nrf_atflags.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/atomic/: nrf_atomic.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/balloc/: nrf_balloc.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/memobj/: nrf_memobj.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/ringbuf/: nrf_ringbuf.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/experimental_section_vars/: nrf_section_iter.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/strerror/: nrf_strerror.c
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/libraries/log/src/: nrf_log_backend_flash.c nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_serial.h nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    $extsource$/NRF/nRF5_SDK_15.3.0_59ac345/components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_soc.c
